# Keil uVision project 2025755182.uvprojx, settings and files
target 2025755182 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2025755182
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\HeaderFiles;..\sysFunction;..\HardWare\LED;..\CMSIS\GD\GD32F4xx\Include;..\HardWare\RTC;..\HardWare\USART;..\HardWare\SPI_FLASH;..\HardWare\SDCARD;..\Fatfs;..\Components\Easy_Button;..\Components\Ring_Buffer;..\HardWare\KEY;..\HardWare\OLED;..\Components\LittleFS;..\HardWare\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group HardWare
    ../HardWare/SDCARD/: sdcard.c
    ../HardWare/OLED/: OLED.c
    ../HardWare/SPI_FLASH/: SPI_FLASH.c lfs_port.c
    ../HardWare/LED/: led_driver.c
    ../HardWare/USART/: usart_driver.c
    ../HardWare/KEY/: key_driver.c
    ../HardWare/RTC/: rtc_driver.c
    ../HardWare/ADC/: adc_dirver.c
  group sysFunction
    ../sysFunction/: Function.c scheduler.c uart_app.c SDcard_app.c data_app.c sampling_control.c data_save.c
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Fatfs
    ../Fatfs/: diskio.c ff.c unicode_new.c
  group Readme
    ../01 Readme/: Readme.txt
  group Component
    ../Components/Ring_Buffer/: ringbuffer.c
    ../Components/LittleFS/: lfs.c lfs_util.c
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDERR 1.2.0
